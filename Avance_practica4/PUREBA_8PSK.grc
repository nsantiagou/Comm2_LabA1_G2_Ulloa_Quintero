options:
  parameters:
    author: com_2_A1_G3
    generate_options: qt_gui
    id: PUREBA_8PSK
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: T
  id: variable
  parameters:
    value: |-
      np.array([-0.77-0.77j, -1+0j, -0.77+0.77j, 0+1j, 0.77+0.77j, 1+0j, 0.77-0.77j, 0-1j]
      )
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: 'Carrier Freq. '
    start: '0'
    step: samp_rate/1000
    stop: samp_rate/8
    value: Rb*4
  states: {}
- name: fd
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Deviation Freq
    start: '0'
    step: samp_rate/1000
    stop: samp_rate/8
    value: Rb
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: m
  id: variable
  parameters:
    value: '8'
  states: {}
- name: nbps
  id: variable
  parameters:
    value: int(math.log(m,2))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: (Rb*Sps)
  states: {}
- name: Menu
  id: qtgui_tab_widget
  parameters:
    gui_hint: 4,0,1,2
    label0: Message
    label1: RF Modulated. Time Domain
    label2: RF Modulated. Freq Domain
    label3: Constellation
    label4: '"PSD (Watts/Hz)"'
    num_tabs: '5'
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*math.pi/m
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/(N*samp_rate)]*N'
    type: float
    vlen: N
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: nbps
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: T
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport math\n\nclass blk(gr.sync_block):  \n    \"\"\"This block is a RF VCO and works as following: …..\"\"\"\n\n    def __init__(self, fc=128000, samp_rate=320000):  \n        gr.sync_block.__init__(\n            self,\n            name='e_RF_VCO_ff',   \n            in_sig=[np.float32, np.float32],\n            out_sig=[np.float32]\n        )\n        self.fc = fc\n        self.samp_rate = samp_rate\n        self.n_m=0\n\n    def work(self, input_items, output_items):\n        A=input_items[0]\n        Q=input_items[1]\n        y=output_items[0]\n        N=len(A)\n        n=np.linspace(self.n_m,self.n_m+N-1,N)\n        self.n_m += N\n        y[:]=A*np.cos(2*math.pi*self.fc*n/self.samp_rate+Q)\n        return len(output_items[0])\n\n\n"
    fc: fc
    samp_rate: samp_rate
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import math

      class blk(gr.sync_block):  
          """This block is a CE VCO or baseband VCO and works as following: ….."""

          def __init__(self,):  
              gr.sync_block.__init__(
                  self,
                  name='e_CE_VCO_fc',   
                  in_sig=[np.float32, np.float32],
                  out_sig=[np.complex64]
              )
              
          def work(self, input_items, output_items):
              A=input_items[0]
              Q=input_items[1]
              y=output_items[0]
              N=len(A)
              y[:]=A*np.exp(1j*Q)
              return len(output_items[0])
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    N: N
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  
          """vector averager. N is the lengh of the vector"""

          def __init__(self, N=1024):
              gr.sync_block.__init__(
                  self,
                  name='e_vec_averager_ff',   
                  in_sig=[(np.float32,N)],
                  out_sig=[(np.float32,N)]
              )
              self.N = N
              self.rows_counter=0
              self.sum=0

          def work(self, input_items, output_items):
              x=input_items[0]
              y=output_items[0]
              self.sum += np.sum(x, axis=0)
              self.rows_counter += len(x)
              y[:]=self.sum/self.rows_counter
              return len(output_items[0])
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: float
    window: '[1]*N'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: fff
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: Menu@3:3,1,1,1
    name: '"CE-Constellation"'
    size: '1024'
    type: complex
    width1: '8'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    gui_hint: Menu@2:2,1,1,1
    label1: RF Modulated Signal
    type: float
    width1: '2'
    ymax: '-35'
    ymin: '-65'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: 1024*8
    gui_hint: Menu@2:3,1,1,1
    label1: CE-Modulated Signal
    type: complex
    width1: '2'
    ymax: '-35'
    ymin: '-65'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Menu@0:3,1,1,1
    label1: p2
    marker1: '0'
    name: '"Message bipolar"'
    size: '16'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Menu@0:2,1,1,1
    label1: p1
    name: Modudating Signal
    size: 16*Sps
    srate: samp_rate
    type: float
    width1: '3'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: Menu@1:2,1,1,1
    label1: Modulating Signal
    label2: RF Modulated signal
    name: Modulating versus RF Modulated Signal
    nconnections: '2'
    size: 16*Sps
    srate: samp_rate
    type: float
    width1: '4'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_time_sink_x_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: Menu@1:3,1,1,1
    label1: I-Signal
    label2: Q-signal
    name: CE Modulated Signal
    size: 16*Sps
    srate: samp_rate
    type: complex
    width1: '2'
    width2: '2'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.1'
    gui_hint: Menu@4:3,0,1,1
    label1: p5
    name: '"PSD (Watts/Hz)"'
    vlen: N
    width1: '3'
    x_axis_label: '"f"'
    x_start: '-samp_rate/2'
    x_step: samp_rate/N
    x_units: '"Hz"'
    y_axis_label: '"Sx(f)"'
    y_units: '"Watss/Hz"'
    ymax: 1/Rb
    ymin: '0'
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: p2
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p3
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p4
  states: {}
- name: virtual_sink_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: p4b
  states: {}
- name: virtual_sink_0_0_0_0_1
  id: virtual_sink
  parameters:
    stream_id: p5
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: p2
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: p3
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: p4
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: p4b
  states: {}
- name: virtual_source_0_1_0_1
  id: virtual_source
  parameters:
    stream_id: p5
  states: {}

connections:
- [analog_const_source_x_0_0, '0', epy_block_0, '0']
- [analog_const_source_x_0_0, '0', epy_block_0_0, '0']
- [analog_random_source_x_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_char_to_float_0, '0', interp_fir_filter_xxx_0, '0']
- [blocks_char_to_float_0, '0', virtual_sink_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_0_1, '0']
- [blocks_multiply_const_vxx_0_1, '0', epy_block_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', epy_block_0_0, '1']
- [blocks_multiply_const_vxx_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_vector_source_x_0, '0', blocks_repack_bits_bb_0, '0']
- [epy_block_0, '0', virtual_sink_0_0_0_0, '0']
- [epy_block_0, '0', virtual_sink_0_0_0_0_1, '0']
- [epy_block_0_0, '0', virtual_sink_0_0_0_0_0, '0']
- [epy_block_0_1, '0', blocks_multiply_const_vxx_1, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0_0_0, '0']
- [virtual_source_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0_1, '0']
- [virtual_source_0_1, '0', qtgui_time_sink_x_0_1_0, '0']
- [virtual_source_0_1_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_1_0, '0', qtgui_time_sink_x_0_1_0, '1']
- [virtual_source_0_1_0_0, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_0_1_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0_1_0_0, '0', qtgui_time_sink_x_0_1_0_0, '0']
- [virtual_source_0_1_0_1, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
